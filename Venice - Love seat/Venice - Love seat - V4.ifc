Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Venice - Love seat - V4.ifc
Time: 2023-11-21T11:31:52
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (19)
Name
 | dd_0 - ObjectType: SketchupGroup
 | dd_1 - ObjectType: SketchupGroup
 | dd_2 - ObjectType: SketchupGroup
 | dd_3 - ObjectType: SketchupGroup
 | dd_4 - ObjectType: SketchupGroup
 | dd_5 - ObjectType: SketchupGroup
 | dd_6 - ObjectType: SketchupGroup
 | dd_7 - ObjectType: SketchupGroup
 | dd_8 - ObjectType: SketchupGroup
 | dd_9 - ObjectType: SketchupGroup
 | dd_10 - ObjectType: SketchupGroup
 | dd_11 - ObjectType: SketchupGroup
 | dd_12 - ObjectType: SketchupGroup
 | dd_13 - ObjectType: SketchupGroup
 | dd_14 - ObjectType: SketchupGroup
 | dd_15 - ObjectType: SketchupGroup
 | dd_16 - ObjectType: SketchupGroup
 | dd_17 - ObjectType: SketchupGroup
 | dd_18 - ObjectType: SketchupGroup
